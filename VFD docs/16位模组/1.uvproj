# Keil uVision project 1.uvproj, settings and files
target 目标 1 (MCS-51)
  device: STC15W408AS STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FF8) CLOCK(35000000) MODP2
  output: 1 +hex
  c flags: Optimize=9 SizeSpeed=1
  group 源组 1
    ./: STARTUP.A51 1.c STC15.H STC_ADC.h STC_EEPROM1T.h IIC.h NEC6121.h
